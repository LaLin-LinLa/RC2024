# Keil uVision project my_foc.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32C103CB GigaDevice
  pack: GigaDevice.GD32C10x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: my_foc +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32C10X
  c include: ..\Core;..\Drivers\CMSIS;..\Drivers\CMSIS\GD\GD32C10x\Include;..\Drivers\GD32C10x_standard_peripheral\Include;..\Src;..\Src_2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/User/MDK-ARM
    ./: startup_gd32c10x.s
  group Application/User/Core
    ../Core/: main.c gd32c10x_it.c system_board.c delay_systick.c delay_timer.c
  group Application/User/Src
    ../Src/: encoder.c pwm_curr.c fsm_task.c foc.c controller.c util.c user_config.c usart.c heap.c calibration.c anticogging.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group Drivers/GD32_STD
    ../Drivers/GD32C10x_standard_peripheral/Source/: gd32c10x_adc.c gd32c10x_bkp.c gd32c10x_can.c gd32c10x_crc.c gd32c10x_ctc.c gd32c10x_dac.c gd32c10x_dbg.c gd32c10x_dma.c gd32c10x_exmc.c gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_fwdgt.c gd32c10x_gpio.c gd32c10x_i2c.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_rtc.c gd32c10x_spi.c gd32c10x_timer.c gd32c10x_usart.c gd32c10x_wwdgt.c
